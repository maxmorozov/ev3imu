# IAR project lsm9ds0.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3U STM8S103F3U
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x64
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: F_MASTER=16000000; STM8S103; std=
  ICCSTM8.CCIncludePath2: src\; ..\..\3rdparty\scmRTOS\core\; ..\..\3rdparty\scmRTOS\port\stm8\iar\; ..\..\3rdparty\stm8s_lib\; ..\..\3rdparty\stm8s_lib\inc\; ..\..\lib\inc\
  ICCSTM8.IccLang: 1
  ASTM8.AsmIncludePath: src
  OBJCOPY.OOCOutputFile: lsm9ds0.hex
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkIcfFile: link\lnkstm8s103f3.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG; F_MASTER=16000000; STM8S103; std=
  OBJCOPY.OOCOutputFile: lsm9ds0.srec
  ILINK.IlinkOutputFile: lsm9ds0.out
  group (top)
    src/: main.cpp
  group lib
    ../../lib/src/utils/: byte_order.asm swap_sample.asm
    ../../lib/src/math/: correction.cpp muldivs161616x.asm scale2le.asm
  group scmRTOS/core
    ../../3rdparty/scmRTOS/core/: os_kernel.cpp os_services.cpp
  group scmRTOS/stm8
    ../../3rdparty/scmRTOS/port/stm8/iar/: os_target.cpp os_target_asm.s
