<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <group>
    <name>lib</name>
    <file>
      <name>$PROJ_DIR$\..\..\lib\src\utils\byte_order.asm</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\lib\src\math\correction.cpp</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\lib\src\math\muldivs161616x.asm</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\lib\src\math\scale2le.asm</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\lib\src\utils\swap_sample.asm</name>
    </file>
  </group>
  <group>
    <name>scmRTOS</name>
    <group>
      <name>core</name>
      <file>
        <name>$PROJ_DIR$\..\..\3rdparty\scmRTOS\core\os_kernel.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\3rdparty\scmRTOS\core\os_services.cpp</name>
      </file>
    </group>
    <group>
      <name>stm8</name>
      <file>
        <name>$PROJ_DIR$\..\..\3rdparty\scmRTOS\port\stm8\iar\os_target.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\3rdparty\scmRTOS\port\stm8\iar\os_target_asm.s</name>
      </file>
    </group>
  </group>
  <file>
    <name>$PROJ_DIR$\src\main.cpp</name>
  </file>
</project>


